# Keil uVision project CloseLoopBLDCMotor.uvproj, settings and files
target CloseLoopBLDCMotor (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E003_BLDCMotorControl +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\Include
  group Source
    ./Code/: N76E003_BLDCMotorControl.c
  group Common
    ../../../Common/: Delay.c Common.c
  group Startup
    ../../../Startup/: STARTUP.A51
